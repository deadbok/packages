## net/git/Config.in
```kconfig
if PACKAGE_git
	config GIT_curl
		bool "Use libcurl"
		default n
		help
			Enables support for more protocols including HTTPS.
endif
```
